#
# Jailhouse, a Linux-based partitioning hypervisor
#
# Copyright (c) Siemens AG, 2018
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require jailhouse.inc

SRC_URI += "file://0001-configs-Add-support-for-MACCHIATObin-board.patch"

SRCREV = "f596aa7355bc2134650544bdf1e13f1f55d3f2fc"
