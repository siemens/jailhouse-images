#
# Jailhouse, a Linux-based partitioning hypervisor
#
# Copyright (c) Siemens AG, 2018-2020
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require u-boot-${PV}.inc

U_BOOT_CONFIG = "mvebu_mcbin-88f8040_defconfig"
U_BOOT_BIN = "u-boot.bin"
