#
# Jailhouse, a Linux-based partitioning hypervisor
#
# Copyright (c) Siemens AG, 2018
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require recipes-kernel/linux/linux-jailhouse_4.19.inc

SRC_URI[sha256sum] = "07ca5f88e1ecd68cd1408780c7cd25fd17002478008af2531f4ed64c827678fa"
SRCREV = "c94c49b84d7a7adca2320d617d3a7721eb753e3b"
