#
# Jailhouse, a Linux-based partitioning hypervisor
#
# Copyright (c) Siemens AG, 2018-2023
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require recipes-kernel/linux/linux-jailhouse_5.15.inc

SRC_URI[sha256sum] = "68036112e0d651351692beabf035aee502954bc6675756813ce1bcd3b27d3544"
SRCREV = "9f943ff23cec02b0b2db9e777197fb298ca2c4aa"
