#
# Jailhouse, a Linux-based partitioning hypervisor
#
# Copyright (c) Siemens AG, 2018
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require recipes-kernel/linux/linux-jailhouse_5.4.inc

SRC_URI[sha256sum] = "c2a9e69f32c017c4d32d7f87d3221232fc9053e8fd94f7e25e8e6867f9be2dd0"
SRCREV = "9caa6a8cab0d7f46475990aaeb7dcc7721547ef0"
